# Repository F6ITU/solderstation

File README.md:

Kicad files for the Soldestation project, 
https://wiki.electrolab.fr/Projets:SolderStationW

## KiCad design station.kicad_pcb

Parts:
AFF2, AFF3, AFF4: SC08-11YWA
C1: 100n
C2, C3: 10n
D1: LED
P1: DIN_5
P2, P3: CONN_17
P4: CONN_2
Q1: IRF7476
Q2, Q3, Q4, Q5: BSN 20
R1: 10k
R2, R7: 5k6
R3, R11, R12, R13: 1k
R4: 100k
R5: 100
R6: 68
R8, R14, R15, R16, R17, R18, R19, R20, R21: 220
SW1, SW2: PUSHBUT_4PIN
SW3: ENC
U1: OPA336
U2: ARDUINO_NANO; DIL20

Connections:
+12V: P4.2 (PM), Q1.1 (S), Q1.2 (S), Q1.3 (S), R1.2
/A: AFF2.1 (a), AFF3.1 (a), AFF4.1 (a), R16.2
/B: AFF2.14 (b), AFF3.14 (b), AFF4.14 (b), R15.2
/C: AFF2.12 (c), AFF3.12 (c), AFF4.12 (c), R14.2
/D: AFF2.10 (d), AFF3.10 (d), AFF4.10 (d), R17.2
/DP: AFF2.9 (DP), AFF3.9 (DP), AFF4.9 (DP), R20.2
/Dot: P2.6, U2.6
/E: AFF2.4 (e), AFF3.4 (e), AFF4.4 (e), R21.2
/E1: P2.5, U2.7
/F: AFF2.2 (f), AFF3.2 (f), AFF4.2 (f), R19.2
/G: AFF2.13 (g), AFF3.13 (g), AFF4.13 (g), R18.2
/K1: Q3.G, R11.2
/K2: Q4.G, R12.2
/K3: Q5.G, R13.2
/L: P2.4, U2.8
/LED: D1.1 (A), R8.2
GND: C1.2, C2.2, C3.2, D1.2 (K), P1.3, P2.2, P2.3, P3.2, P3.3, P4.1, Q2.S, Q3.S, Q4.S, Q5.S, R4.2, R5.2, SW1.2, SW2.2, SW3.2 (Gnd), SW3.6 (gnd), SW3.7 (gnd), U1.4 (V-), U2.14, U2.19
unnamed: P3.12, R14.1
unnamed: Q1.4 (G), Q2.D, R1.1
unnamed: P3.13, R13.1
unnamed: P3.14, R12.1
unnamed: P3.15, R11.1
unnamed: P3.11, R15.1
unnamed: P3.10, R16.1
unnamed: C3.1, R7.2, U2.11
unnamed: C1.1, U1.7 (V+), U2.12
unnamed: R3.2, U2.21
unnamed: Q2.G, R3.1
unnamed: P3.7, R19.1
unnamed: P3.9, R17.1
unnamed: P3.8, R18.1
unnamed: P3.6, R20.1
unnamed: P3.5, R21.1
unnamed: P3.4, R8.1
unnamed: R6.2, R7.1, U1.6
unnamed: P1.1, R2.1
unnamed: C2.1, R2.2, R4.1, U1.3 (+)
unnamed: R5.1, R6.1, U1.2 (-)
unnamed: P2.17, U2.1
unnamed: P2.16, U2.30
unnamed: P2.15, U2.29
unnamed: P2.14, U2.28
unnamed: P2.13, U2.27
unnamed: P2.12, U2.26
unnamed: P2.11, U2.25
unnamed: P2.10, U2.24
unnamed: P2.7, U2.20
unnamed: P2.8, U2.22
unnamed: P2.9, U2.23
unnamed: P3.16, SW1.1, SW3.1 (A)
unnamed: P1.2, U2.9
unnamed: P3.17, SW2.1, SW3.3 (B)
unnamed: P1.4, P1.5, Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D)
unnamed: AFF4.3 (C.A.), AFF4.5 (C.A.), AFF4.11 (C.A.), AFF4.16 (C.A.), Q5.D
unnamed: AFF2.3 (C.A.), AFF2.5 (C.A.), AFF2.11 (C.A.), AFF2.16 (C.A.), Q3.D
unnamed: AFF3.3 (C.A.), AFF3.5 (C.A.), AFF3.11 (C.A.), AFF3.16 (C.A.), Q4.D

Notes on the sheet:
SdBy SW

Board: 2 copper layers, 44 parts (0 on the bottom side), 56 nets.

Other parts of the board:
1PIN, 1PIN#2, 1PIN#3, 1PIN#4: P***; 1pin

## Commit log

2017-03-21 12-03-2015 last version
